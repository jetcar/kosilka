## firmware-esp32/sdkconfig.defaults
```kconfig
CONFIG_USB_CDC_ENABLED=y
CONFIG_LOG_DEFAULT_LEVEL_INFO=y
CONFIG_FREERTOS_HZ=1000
CONFIG_ESP_TASK_WDT=y
```
